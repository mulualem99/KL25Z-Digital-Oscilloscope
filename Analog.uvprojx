# Keil uVision project Analog.uvprojx, settings and files
target KL25Z Flash (6190000::V6.19::ARMCLANG)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.1
  cpu: IRAM(0x1FFFF000,0x00004000) IROM(0x00000000,0x00020000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Analog
  c flags: Optim=2 v6Lang=3 v6LangP=5
  c include: .\inc
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group Source Files
    ./src/: main.c adc.c Dma.c gpio.c PIT.c spi.c tft.c
  group Include Files
    ./inc/: adc.h Dma.h gpio.h pit.h SPI.h tft.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.5.0
